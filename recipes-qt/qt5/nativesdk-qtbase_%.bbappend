PACKAGECONFIG += "gui"
